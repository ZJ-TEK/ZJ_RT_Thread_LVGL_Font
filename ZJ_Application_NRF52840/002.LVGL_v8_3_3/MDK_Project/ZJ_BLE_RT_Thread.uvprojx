# Keil uVision project ZJ_BLE_RT_Thread.uvprojx, settings and files
target ZJ_BLE_RT_Thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_ble_rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_ENTRY_POINT=entry FLOAT_ABI_HARD CONFIG_GPIO_AS_PINRESET NRF52840_XXAA LV_CONF_INCLUDE_SIMPLE LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --reduce_paths --diag_suppress=188,546,68,111 --locale=english
  c include: ../../../RT_THREAD/include;../../../RT_THREAD/libcpu/arm/cortex-m4;../../../RT_THREAD/libcpu/arm/common;../../../RT_THREAD/components/finsh;../../../RT_THREAD/components/drivers/include;../../../NORDIC_SDK/components;../../../NORDIC_SDK/components/drivers_nrf/nrf_soc_nosd;../../../NORDIC_SDK/components/libraries/atomic;../../../NORDIC_SDK/components/libraries/balloc;../../../NORDIC_SDK/components/libraries/experimental_log;../../../NORDIC_SDK/components/libraries/experimental_log/src;../../../NORDIC_SDK/components/libraries/experimental_memobj;../../../NORDIC_SDK/components/libraries/experimental_section_vars;../../../NORDIC_SDK/components/libraries/strerror;../../../NORDIC_SDK/components/libraries/uart;../../../NORDIC_SDK/components/libraries/util;../../../NORDIC_SDK/components/libraries/timer;../../../NORDIC_SDK/components/toolchain/cmsis/include;../../../NORDIC_SDK/integration/nrfx;../../../NORDIC_SDK/integration/nrfx/legacy;../../../NORDIC_SDK/modules/nrfx;../../../NORDIC_SDK/modules/nrfx/hal;../../../NORDIC_SDK/modules/nrfx/mdk;../../../NORDIC_SDK/modules/nrfx/drivers/include;../../../NORDIC_SDK/external/fprintf;../../../NORDIC_SDK/external/segger_rtt;../../../RT_THREAD_NRF_HAL/inc;../config;../RT_Thread_Startup;../applications/app_init;../applications/app_gpio;../applications/app_event;../startups;..\bsp_driver\include;..\font;..\..\..\RT_THREAD\components\drivers\i2c;..\..\..\RT_THREAD\components\drivers\include\drivers;../../../RT_THREAD/components/drivers/include;..\..\..\lvgl;..\..\..\lvgl\src;..\..\..\lvgl\examples\porting;..\littlevgl\vgl_rtt_drv;..\littlevgl\vgl_app;..\language;..\lightmeter;..\lightmeter\VEML7700
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../applications/finsh_test/: finsh_test.c
    ../applications/app_gpio/: app_gpio.c
    ../config/: rtconfig.h sdk_config.h
    ../../../lvgl/: lv_conf.h
  group Startup
    ../../../NORDIC_SDK/modules/nrfx/mdk/: system_nrf52840.c arm_startup_nrf52840.s
  group RT_Thread_Startup
    ../RT_Thread_Startup/: board.c
  group BSP_Driver
    ../bsp_driver/src/: bsp_qspi_dri.c bsp_lcd_ie3130b_dri.c
  group nRF_Log
    ../../../NORDIC_SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../NORDIC_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../NORDIC_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../NORDIC_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../NORDIC_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../NORDIC_SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../NORDIC_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../NORDIC_SDK/components/libraries/timer/: app_timer_rtthread.c
  group nRF_Drivers
    ../../../NORDIC_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_twi.c
    ../../../NORDIC_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_qspi.c nrfx_spim.c nrfx_twim.c
  group nRF_Segger_RTT
    ../../../NORDIC_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_keil.c SEGGER_RTT_printf.c
  group CORTEX-M4
    ../../../RT_THREAD/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
  group Kernel
    ../../../RT_THREAD/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group DeviceDriver
    ../../../RT_THREAD/components/drivers/src/: completion.c dataqueue.c
    ../../../RT_THREAD/components/drivers/serial/: serial.c
    ../../../RT_THREAD/components/drivers/misc/: pin.c
    ../../../RT_THREAD/components/drivers/i2c/: i2c_dev.c i2c_core.c
  group finsh_shell
    ../../../RT_THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT_Thread_nRF_HAL
    ../../../RT_THREAD_NRF_HAL/src/: rt_nrf_hal_uart.c rt_nrf_hal_gpio.c rt_nrf_hal_iic.c rt_nrf_hal_lcd.c
  group font
    ../font/: cmap_emoji_font_32_8Bpp.c cmap_Full_HarmonyOS_Sans_SC_KR_Regular_24_2Bpp.c cmap_icon_font_32_8Bpp.c ext_font_app.c ext_font_engine.c fake_font_24_2Bpp.c cmap_Full_HarmonyOS_Sans_SC_Medium_24_2Bpp.c cmap_HarmonyOS_Sans_SC_Medium_24_2Bpp.c inner_HarmonyOS_Sans_SC_Medium_24_2Bpp.c
  group LVGL
    ../../../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../../lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../../lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../lvgl/src/extra/others/msg/: lv_msg.c
    ../../../lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/extra/widgets/led/: lv_led.c
    ../../../lvgl/src/extra/widgets/list/: lv_list.c
    ../../../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/extra/widgets/span/: lv_span.c
    ../../../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/extra/widgets/win/: lv_win.c
    ../../../lvgl/src/extra/: lv_extra.c
    ../../../lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVLG_PORT
    ../littlevgl/vgl_rtt_drv/: lvgl_rtt_drv.c
  group LVGL_APP
    ../littlevgl/vgl_app/: lvgl_rtt_main.c
  group language
    ../language/: lang_de_DE.c lang_en_us.c lang_es_ES.c lang_fr_FR.c lang_ja_jp.c lang_pt_PT.c lang_ru_RU.c lang_zh_cn.c lang_zh_hk.c language.c lang_it_IT.c
