# Keil uVision project ZJ_NimBLE_LittlevGL_RT_Thread.uvprojx, settings and files
target ZJ_NimBLE_LittlevGL_RT_Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_nimble_rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET RT_USING_ARM_LIBC  NIMBLE_CFG_CONTROLLER=1 NRF52840_XXAA RETARGET_ENABLED
  c misc: --reduce_paths --gnu
  c include: ..\..\..\RT_THREAD\components\CMSIS\Include;..\..\..\NORDIC_HAL\nrfx;..\..\..\NORDIC_HAL\nrfx\drivers;..\..\..\NORDIC_HAL\nrfx\drivers\include;..\..\..\NORDIC_HAL\nrfx\drivers\src\prs;..\..\..\NORDIC_HAL\nrfx\hal;..\..\..\NORDIC_HAL\nrfx\mdk;..\..\..\NORDIC_HAL\nrfx\soc;..\..\..\NORDIC_HAL\segger_rtt;..\..\..\RT_THREAD\include;..\..\..\RT_THREAD\libcpu\arm\common;..\..\..\RT_THREAD\libcpu\arm\cortex-m4;..\..\..\RT_THREAD\components\dfs\include;..\..\..\RT_THREAD\components\dfs\filesystems\devfs;..\..\..\RT_THREAD\components\drivers\include;..\..\..\RT_THREAD\components\drivers\include;..\..\..\RT_THREAD\components\drivers\include;..\..\..\RT_THREAD\components\finsh;..\..\..\RT_THREAD\components\libc\compilers\armlibc;..\..\..\RT_THREAD\components\libc\compilers\common;..\..\..\LittlevGL;..\..\..\LittlevGL\lvgl;..\..\..\LittlevGL\lvgl\src;..\..\..\LittlevGL\lvgl\src\lv_core;..\..\..\LittlevGL\lvgl\src\lv_draw;..\..\..\LittlevGL\lvgl\src\lv_font;..\..\..\LittlevGL\lvgl\src\lv_hal;..\..\..\LittlevGL\lvgl\src\lv_misc;..\..\..\LittlevGL\lvgl\src\lv_objx;..\..\..\LittlevGL\lvgl\src\lv_themes;..\..\..\LittlevGL\example;..\config;..\applications;..\RT_Thread_Startup;..\nordic_misc;..\applications\app_init;..\applications\app_event;..\bsp_driver\inc;..\..\..\RT_THREAD_NRF_HAL\inc;..\..\..\NORDIC_HAL\util;..\littlevgl\vgl_rtt_drv;..\littlevgl\vgl_app;..\font
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group application
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../config/: rtconfig.h nrfx_config.h
    ../../../LittlevGL/: lv_conf.h
  group rtthread_startup
    ../RT_Thread_Startup/: board.c
  group rtthread_kernel
    ../../../RT_THREAD/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group finsh_shell
    ../../../RT_THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group DeviceDriver
    ../../../RT_THREAD/components/drivers/src/: completion.c dataqueue.c ringbuffer.c
    ../../../RT_THREAD/components/drivers/serial/: serial.c
    ../../../RT_THREAD/components/drivers/misc/: pin.c
  group cortex_m4
    ../../../RT_THREAD/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
  group arm_libc
    ../../../RT_THREAD/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../RT_THREAD/components/libc/compilers/common/: gmtime_r.c
  group nrf_segger_rtt
    ../../../NORDIC_HAL/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Device.c SEGGER_RTT_printf.c
  group nrf_hal
    ../../../NORDIC_HAL/nrfx/mdk/: arm_startup_nrf52840.s system_nrf52840.c
    ../../../NORDIC_HAL/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_rtc.c nrfx_qspi.c nrfx_spim.c
    ../nordic_misc/: nrfx_glue.c
  group nrf_rtt_hal
    ../../../RT_THREAD_NRF_HAL/src/: rt_nrf_hal_gpio.c rt_nrf_hal_lcd.c rt_nrf_hal_qspi_flash.c
  group nrf_driver
    ../bsp_driver/src/: bsp_lcd_ie3130b_dri.c
  group littlevgl
    ../../../LittlevGL/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../../LittlevGL/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../../../LittlevGL/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../../../LittlevGL/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../LittlevGL/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../../../LittlevGL/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../../../LittlevGL/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group littlevgl_rtt
    ../littlevgl/vgl_rtt_drv/: lvgl_rtt_drv.c
  group littlevgl_app
    ../littlevgl/vgl_app/: lvgl_rtt_main.c
  group font
    ../font/: cmap_fHarmonyOS_Sans_SC_Medium_24_2Bpp.c cmap_HarmonyOS_Sans_SC_Medium_24_2Bpp.c ext_font_app.c ext_font_engine.c fake_font_24_2Bpp.c HarmonyOS_Sans_SC_Medium_24_2Bpp.c
